SRC_URI += " file://bsp.cfg"
SRC_URI += " file://i2c.cfg"

FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

